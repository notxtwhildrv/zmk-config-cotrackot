## boards/shields/cotrackot/Kconfig.defconfig
```kconfig
if SHIELD_COTRACKOT

config ZMK_KEYBOARD_NAME
    default "cotrackot"

config ZMK_BLE
    default y

endif
```
